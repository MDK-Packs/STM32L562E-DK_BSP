# Keil uVision project Blinky.uvprojx, settings and files
target STM32L562E-DK (6210000::V6.21::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT6: RAM 0x2003e000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x3e000
  memory RVCT10: RAM 0x30000000 size 0x40000
  group App
    ./: Blinky.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Src/: main.c stm32l5xx_it.c
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/Inc/: stm32l5xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32L562QEIxQ/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:Components:LSM6DSO 1.3.0, Board Support:Components:ST7789H2 2.0.2, Board Support:Drivers:BUS 1.1.1, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:LCD 1.1.1, Board Support:Drivers:Motion Sensors 1.1.1, CMSIS Driver:VIO:Board 2.0.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:Common 1.0.4, Device:STM32Cube HAL:Cortex 1.0.4, Device:STM32Cube HAL:DMA 1.0.4, Device:STM32Cube HAL:EXTI 1.0.4, Device:STM32Cube HAL:Flash 1.0.4, Device:STM32Cube HAL:GPIO 1.0.4, Device:STM32Cube HAL:I2C 1.0.4, Device:STM32Cube HAL:PWR 1.0.4, Device:STM32Cube HAL:RCC 1.0.4, Device:STM32Cube HAL:SRAM 1.0.4, Device:STM32Cube HAL:UART 1.0.4, Device:Startup 1.0.3
